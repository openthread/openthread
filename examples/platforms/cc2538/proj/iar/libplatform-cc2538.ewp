# IAR project libplatform-cc2538.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\src\core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: libplatform-cc2538.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ../../: alarm.c cc2538-reg.h logging.c platform.c platform.h radio.c random.c serial.c startup-iar.c
