# IAR project libopenthread-cli.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\src\core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: libopenthread-cli.out
  ILINK.IlinkAdditionalLibs: Debug\Exe\libopenthread.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group cli
    ../../../../../src/cli/: cli.cpp cli.hpp cli_serial.cpp cli_serial.hpp cli_server.hpp cli_udp.cpp cli_udp.hpp
