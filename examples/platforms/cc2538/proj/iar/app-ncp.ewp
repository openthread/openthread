# IAR project app-ncp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\src\core; ..\..\..\..\..\examples\platforms; ..\..\..\..\..\examples\platforms\cc2538; ..\..\..\..\..\third_party\mbedtls\repo\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ot-ncp.srec
  ILINK.IlinkOutputFile: ot-ncp.out
  ILINK.IlinkIcfFile: ..\..\link\cx2538xf53.icf
  ILINK.IlinkAdditionalLibs: Debug/Exe/libopenthread.a; Debug/Exe/libopenthread-ncp.a; Debug/Exe/libmbedtls.a; Debug/Exe/libplatform-cc2538.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group app
    ../../../../apps/ncp/: main.c
  group link
    ../../link/: cx2538xf53.icf
