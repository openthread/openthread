# IAR project libopenthread-ncp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\src\core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: libopenthread-ncp.out
  ILINK.IlinkAdditionalLibs: Debug\Exe\libopenthread.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group ncp
    ../../../../../src/ncp/: flen.cpp flen.hpp hdlc.cpp hdlc.hpp ncp.cpp ncp.hpp ncp_base.cpp ncp_base.hpp PROTOCOL.md spinel.c spinel.h
