# IAR project libopenthread.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\include; ..\..\..\..\..\src\core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: libopenthread.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ../../../../../src/core/: openthread-core-config.h openthread.cpp
  group core/coap
    ../../../../../src/core/coap/: coap_header.cpp coap_header.hpp coap_server.cpp coap_server.hpp
  group core/common
    ../../../../../src/core/common/: code_utils.hpp debug.hpp encoding.hpp logging.cpp logging.hpp message.cpp message.hpp new.hpp tasklet.cpp tasklet.hpp timer.cpp timer.hpp
  group core/crypto
    ../../../../../src/core/crypto/: aes_ccm.cpp aes_ccm.hpp
  group core/mac
    ../../../../../src/core/mac/: mac.cpp mac.hpp mac_frame.cpp mac_frame.hpp mac_whitelist.cpp mac_whitelist.hpp
  group core/net
    ../../../../../src/core/net/: icmp6.cpp icmp6.hpp ip6.cpp ip6.hpp ip6_address.cpp ip6_address.hpp ip6_filter.cpp ip6_filter.hpp ip6_mpl.cpp ip6_mpl.hpp ip6_routes.cpp ip6_routes.hpp netif.cpp netif.hpp socket.hpp udp6.cpp udp6.hpp
  group core/thread
    ../../../../../src/core/thread/: address_resolver.cpp address_resolver.hpp key_manager.cpp key_manager.hpp link_quality.cpp link_quality.hpp lowpan.cpp lowpan.hpp mesh_forwarder.cpp mesh_forwarder.hpp mle.cpp mle.hpp mle_constants.hpp mle_router.cpp mle_router.hpp mle_tlvs.cpp mle_tlvs.hpp network_data.cpp network_data.hpp network_data_leader.cpp network_data_leader.hpp network_data_local.cpp network_data_local.hpp network_data_tlvs.hpp thread_netif.cpp thread_netif.hpp thread_tlvs.cpp thread_tlvs.hpp thread_uris.hpp topology.hpp
  group include
    ../../../../../include/: openthread-types.h openthread.h
  group include/cli
    ../../../../../include/cli/: cli-serial.h
  group include/crypto
    ../../../../../include/crypto/: aes_ecb.h hmac_sha256.h
  group include/ncp
    ../../../../../include/ncp/: ncp.h
  group include/platform
    ../../../../../include/platform/: alarm.h logging.h radio.h random.h serial.h toolchain.h
